DESCRIPTION = "Games for bootlin"

LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = "ninvaders"
