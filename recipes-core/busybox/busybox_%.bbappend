FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://my_busybox.cfg"
